inherit image_types_fsl_tee

IMAGE_INSTALL += " \
        packagegroup-fsl-optee \
        "
