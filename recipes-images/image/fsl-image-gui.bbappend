inherit image_types_fsl_tee

