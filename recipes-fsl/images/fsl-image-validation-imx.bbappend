IMAGE_INSTALL += " \
        packagegroup-fsl-optee \
        "
